# IAR project x-cube-n6-ai-visual-object-tracking-dk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: STM32N657xx; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; VECT_TAB_SRAM; USE_IMX335_SENSOR; USE_VD66GY_SENSOR; USE_VD55G1_SENSOR; USE_VD1943_SENSOR; STM32N6570_DK_REV; TX_MAX_PARALLEL_NETWORKS=1; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_OSAL=LL_ATON_OSAL_FREERTOS; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1; APP_HAS_PARALLEL_NETWORKS=0; FEAT_FREERTOS
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\Model; ..\..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc; ..\..\STM32Cube_FW_N6\Drivers\STM32N6xx_HAL_Driver\Inc\Legacy; ..\..\STM32Cube_FW_N6\Drivers\CMSIS\Device\ST\STM32N6xx\Include; ..\..\STM32Cube_FW_N6\Drivers\CMSIS\Include; ..\..\STM32Cube_FW_N6\Drivers\CMSIS\DSP\Include; ..\..\STM32Cube_FW_N6\Drivers\BSP\Components\Common; ..\..\STM32Cube_FW_N6\Drivers\BSP\STM32N6570-DK; ..\..\STM32Cube_FW_N6\Utilities\lcd; ..\..\Lib\stedgeai-lib\Inc; ..\..\Lib\stedgeai-lib\Npu\ll_aton; ..\..\Lib\stedgeai-lib\Npu\Devices\STM32N6xx; ..\..\Lib\stm32-vision-models-postprocessing\lib_vision_models_pp\Inc; ..\..\Lib\ai-postprocessing-wrapper; ..\..\Lib\stm32-mw-camera; ..\..\Lib\stm32-mw-camera\sensors; ..\..\Lib\stm32-mw-camera\sensors\imx335; ..\..\Lib\stm32-mw-camera\sensors\vd55g1; ..\..\Lib\stm32-mw-camera\sensors\vd6g; ..\..\Lib\stm32-mw-camera\sensors\vd1943; ..\..\Lib\stm32-mw-camera\ISP_Library\isp\Inc; ..\..\Lib\stm32-mw-freertos\Source\include; ..\..\Lib\stm32-mw-freertos\Source\portable\GCC\ARM_CM55_NTZ\non_secure; ..\..\Lib\NemaGFX\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: x-cube-n6-ai-visual-object-tracking-dk.bin
  ILINK.IlinkOutputFile: x-cube-n6-ai-visual-object-tracking-dk.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\stedgeai-lib\Lib\ABI2.1\ARMCortexM55\NetworkRuntime1201_CM55_IAR.a; ..\..\Lib\NemaGFX\lib\core\cortex_m55\IAR9.x\nemagfx_core_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM/Src
    ../Src/: console.c freertos_libc.c startup_stm32n657xx.s
  group Lib/ai-postprocessing-wrapper
    ../../Lib/ai-postprocessing-wrapper/: app_postprocess_vot_lighttrackm_uf.c
  group Lib/stedgeai-lib/Npu/Devices/STM32N6xx
    ../../Lib/stedgeai-lib/Npu/Devices/STM32N6xx/: mcu_cache.c npu_cache.c
  group Lib/stedgeai-lib/Npu/ll_aton
    ../../Lib/stedgeai-lib/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_cipher.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_osal_freertos.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_stai_internal.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Lib/stm32-mw-camera
    ../../Lib/stm32-mw-camera/: cmw_camera.c cmw_utils.c
  group Lib/stm32-mw-camera/ISP_Library/isp/Src
    ../../Lib/stm32-mw-camera/ISP_Library/isp/Src/: isp_ae_algo.c isp_algo.c isp_awb_algo.c isp_cmd_parser.c isp_core.c isp_services.c isp_tool_com.c
  group Lib/stm32-mw-camera/sensors
    ../../Lib/stm32-mw-camera/sensors/: cmw_imx335.c cmw_vd1943.c cmw_vd55g1.c cmw_vd66gy.c
  group Lib/stm32-mw-camera/sensors/imx335
    ../../Lib/stm32-mw-camera/sensors/imx335/: imx335.c imx335_reg.c
  group Lib/stm32-mw-camera/sensors/vd1943
    ../../Lib/stm32-mw-camera/sensors/vd1943/: vd1943.c
  group Lib/stm32-mw-camera/sensors/vd55g1
    ../../Lib/stm32-mw-camera/sensors/vd55g1/: vd55g1.c
  group Lib/stm32-mw-camera/sensors/vd6g
    ../../Lib/stm32-mw-camera/sensors/vd6g/: vd6g.c
  group Lib/stm32-mw-freertos/Source
    ../../Lib/stm32-mw-freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Lib/stm32-mw-freertos/Source/portable/IAR/ARM_CM55_NTZ/non_secure
    ../../Lib/stm32-mw-freertos/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Lib/stm32-vision-models-postprocessing/lib_vision_models_pp/Src
    ../../Lib/stm32-vision-models-postprocessing/lib_vision_models_pp/Src/: vision_models_pp.c vision_models_pp_maxi_if32.c vot_lighttrackm_pp.c
  group Model
    ../../Model/: stai_vot_split2.c stai_vot_template.c vot_split2.c vot_template.c
  group Src
    ../../Src/: app.c app_cam.c app_fuseprogramming.c freertos_bsp.c main.c nema_hal_freertos.c stm32_lcd_ex.c stm32n6xx_it.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx
    ../../STM32Cube_FW_N6/Drivers/BSP/Components/aps256xx/: aps256xx.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/gt911
    ../../STM32Cube_FW_N6/Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
  group STM32Cube_FW_N6/Drivers/BSP/Components/mx66uw1g45g
    ../../STM32Cube_FW_N6/Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
  group STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK
    ../../STM32Cube_FW_N6/Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_lcd.c stm32n6570_discovery_ts.c stm32n6570_discovery_xspi.c
  group STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates
    ../../STM32Cube_FW_N6/Drivers/CMSIS/Device/ST/STM32N6xx/Source/Templates/: system_stm32n6xx_fsbl.c
  group STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src
    ../../STM32Cube_FW_N6/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_bsec.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gfxmmu.c stm32n6xx_hal_gpio.c stm32n6xx_hal_gpu2d.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pcd.c stm32n6xx_hal_pcd_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_ramcfg.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_spi.c stm32n6xx_hal_tim.c stm32n6xx_hal_uart.c stm32n6xx_hal_xspi.c stm32n6xx_ll_usb.c
  group STM32Cube_FW_N6/Utilities/lcd
    ../../STM32Cube_FW_N6/Utilities/lcd/: stm32_lcd.c
